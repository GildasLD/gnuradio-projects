options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: antenna_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '8'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: channel_freq + center_freq_offset
  states: {}
- name: center_freq_offset
  id: variable
  parameters:
    value: 400E3
  states: {state: disabled}
- name: center_freq_offset
  id: variable_qtgui_range
  parameters:
    start: '90000'
    step: '1000'
    stop: '1000000'
    value: '116000'
  states: {}
- name: chan_width
  id: variable
  parameters:
    value: 200E3
  states: {}
- name: channel_freq
  id: variable_qtgui_range
  parameters:
    label: channel_freq
    start: '87600000'
    step: '150000'
    stop: '107700000'
    value: '91700000'
  states: {}
- name: channel_freq_
  id: variable
  parameters:
    value: 91.7E6
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    start: '80000'
    step: '1000'
    stop: '122000'
    value: '101000'
  states: {}
- name: decimation_factor
  id: variable
  parameters:
    value: int(samp_rate / chan_width)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2E6
  states: {state: disabled}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    start: '1000000'
    step: '100000'
    stop: '3000000'
    value: '2000000'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: transition_width
    start: '5000'
    step: '500'
    stop: '100000'
    value: '10000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: center_freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: 480E3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample3: FORMAT_OPUS
    file: /home/gildas/Musique/radio_classique_2023-04-15___03_44.flac
    format: FORMAT_OGG
    samp_rate: '48000'
  states: {state: disabled}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: decimation_factor
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: decimation_factor
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: antenna_gain
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: antenna_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    samp_per_symbol: '15'
    size: '2048'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.1'
    vlen: '1'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: output
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: output
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_histogram_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_number_sink_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [filter_fft_low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_eye_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
